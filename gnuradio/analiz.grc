options:
  parameters:
    author: mineev
    generate_options: qt_gui
    id: analiz
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '70000000'
    step: samp_rate / 2
    stop: '220000000'
    value: '70000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: frequency
    gain: '8'
    samp_rate: samp_rate
    type: fc32
    vga: '4'
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
