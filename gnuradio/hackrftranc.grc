options:
  parameters:
    author: mineev
    generate_options: qt_gui
    id: hackrftranc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: base_frecuency
  id: variable
  parameters:
    value: '90000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"driver=hackrf"'
    bb_gain0: '20'
    freq0: base_frecuency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
